# IAR project RT106X.ewp, settings and files
configuration nor_sdram_zf_dtcm (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\CODE; ..\..\..\Libraries\nxp_libraries\CMSIS\Include; ..\..\..\Libraries\nxp_libraries\cmsis_drivers; ..\..\..\Libraries\nxp_libraries\drives; ..\..\..\Libraries\nxp_libraries\startup; ..\..\..\Libraries\nxp_libraries\startup\IAR-ARM; ..\..\..\Libraries\nxp_libraries\utilities; ..\..\..\Libraries\nxp_libraries\utilities\debug_console; ..\..\..\Libraries\nxp_libraries\utilities\str; ..\..\..\Libraries\nxp_libraries\xip; ..\..\..\Libraries\nxp_libraries\components\serial_manager; ..\..\..\Libraries\nxp_libraries\components\serial_manager\usb_cdc_adapter; ..\..\..\Libraries\nxp_libraries\components\uart; ..\..\..\Libraries\nxp_libraries\components\lists; ..\..\..\Libraries\nxp_libraries\deceive; ..\..\..\Libraries\seekfree_libraries; ..\..\..\Libraries\seekfree_peripheral; ..\..\..\Libraries\seekfree_libraries\common; ..\..\..\Libraries\seekfree_libraries\board; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\HardWare\Tracker; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\HardWare\OpenArt; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\HardWare\HWT101; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\HardWare\BlueTooth; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\HardWare; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\HardWare\Key; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\HardWare\Motor; F:\工训\Seekfree_RT1064_Opensource_Library\Projecct\USER\src\Application
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\..\Libraries\librares\startup\IAR-ARM
  OBJCOPY.OOCOutputFile: RT106X.srec
  ILINK.IlinkOutputFile: RT106X.out
  ILINK.IlinkIcfFile: ..\..\IAR\icf\MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group _Algorithm
    ../../USER/src/Algorithm/: Algorithm.h
  group _Algorithm/KalmanFilter
    ../../USER/src/Algorithm/KalmanFilter/: KalmanFilter.c KalmanFilter.h
  group _Algorithm/PID
    ../../USER/src/Algorithm/PID/: PID.c PID.h
  group _Application
    ../../USER/src/Application/: Application.h
  group _Application/PathIntegral
    ../../USER/src/Application/PathIntegral/: PathIntegral.c PathIntegral.h
  group _Application/SliceManager
    ../../USER/src/Application/SliceManager/: SliceManager.c SliceManager.h
  group _Application/SliceUpdater
    ../../USER/src/Application/SliceUpdater/: SliceUpdater.c SliceUpdater.h
  group _DataStructure
    ../../USER/src/DataStructure/: DataStructure.h
  group _DataStructure/cJSON
    ../../USER/src/DataStructure/cJSON/: cJSON.c cJSON.h
  group _DataStructure/KB_Ex
    ../../USER/src/DataStructure/KB_Ex/: KB_Ex.c KB_Ex.h
  group _HardWare
    ../../USER/src/HardWare/: Config.h Dependency.h HardWare.c HardWare.h
  group _HardWare/BlueTooth
    ../../USER/src/HardWare/BlueTooth/: BlueTooth.c BlueTooth.h
  group _HardWare/ESP8266
    ../../USER/src/HardWare/ESP8266/: ESP8266.c ESP8266.h
  group _HardWare/HWT101
    ../../USER/src/HardWare/HWT101/: HWT101.c HWT101.h
  group _HardWare/Key
    ../../USER/src/HardWare/Key/: Key.c Key.h
  group _HardWare/Motor
    ../../USER/src/HardWare/Motor/: Motor.c Motor.h
  group _HardWare/OpenArt
    ../../USER/src/HardWare/OpenArt/: OpenArt.c OpenArt.h
  group _HardWare/SYN6288
    ../../USER/src/HardWare/SYN6288/: SYN6288.c SYN6288.h
  group _HardWare/Tracer
    ../../USER/src/HardWare/Tracer/: Tracer.c Tracer.h
  group _Math
    ../../USER/src/Math/: KMath.h
  group _Math/Vector2
    ../../USER/src/Math/Vector2/: Vector2.c Vector2.h
  group board
    ../../../Libraries/seekfree_libraries/board/: board.c board.h clock_config.c pin_mux.c
  group components
    ../../../Libraries/nxp_libraries/components/lists/: generic_list.c generic_list.h
    ../../../Libraries/nxp_libraries/components/uart/: lpuart_adapter.c uart.h
    ../../../Libraries/nxp_libraries/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group deceive
    ../../../Libraries/nxp_libraries/deceive/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
  group doc
    ../../../Libraries/doc/: read me.txt version.txt
  group drives
    ../../../Libraries/nxp_libraries/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group seekfree_libraries
    ../../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
    ../../../Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_csi.c zf_csi.h zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_iomuxc.c zf_iomuxc.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_qtimer.c zf_qtimer.h zf_rom_api.c zf_rom_api.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_uart.c zf_uart.h zf_vector.c zf_vector.h
  group seekfree_peripheral
    ../../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_IPS200_PARALLEL8.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_MT9V03X_CSI.c SEEKFREE_MT9V03X_CSI.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_SCC8660.c SEEKFREE_SCC8660.h SEEKFREE_SCC8660_CSI.c SEEKFREE_SCC8660_CSI.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_W25QXXJV.c SEEKFREE_W25QXXJV.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group startup
    ../../../Libraries/nxp_libraries/startup/IAR-ARM/: startup_MIMXRT1064.s
  group user_c
    ../../USER/src/: isr.c main.c
  group user_h
    ../../../Libraries/seekfree_libraries/: headfile.h
    ../../USER/inc/: isr.h RT106X_config.h
  group utilities
    ../../../Libraries/nxp_libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_notifier.h fsl_sbrk.c fsl_shell.c fsl_shell.h usb_device_config.h
    ../../../Libraries/nxp_libraries/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../Libraries/nxp_libraries/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../Libraries/nxp_libraries/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
